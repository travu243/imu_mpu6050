# Keil uVision project la_ban.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: la_ban +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\config;.\lib\core;.\lib\hardware\KEY;.\lib\hardware\LED;.\lib\hardware\MPU6050;.\lib\hardware\MPU6050\eMPL;.\lib\STM32F10x_FWLib\inc;.\lib\system\delay;.\lib\system\sys;.\lib\system\usart;..\New folder
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group config
    ./lib/config/: stm32f10x_it.c system_stm32f10x.c
  group core
    ./lib/core/: core_cm3.c startup_stm32f10x_hd.s
  group hardware
    ./lib/hardware/LED/: led.c
    ./lib/hardware/MPU6050/: mpu6050.c mpuiic.c
    ./lib/hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32F10x_FWLib
    ./lib/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
  group system
    ./lib/system/delay/: delay.c
    ./lib/system/sys/: sys.c
    ./lib/system/usart/: usart.c
